# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: -AT32F403ARGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.2.1
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND, USE_STDPERIPH_DRIVER, RT_USING_ARMLIBC, AT32F403ARGT7, RT_USING_LIBC, __STDC_LIMIT_MACROS
  c misc: --gnu
  c include: ..\..\..\components\libc\posix\io\stdio;applications\app_task\can_task\inc;..\..\..\components\drivers\include;board\inc;applications\components\gnss_interface\inc;..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\components\dfs\dfs_v1\filesystems\elmfat;..\..\..\components\drivers\include;applications\app_task\comp_task;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\libraries\usbd_library\inc;applications\app_task\demo_cmd;packages\nmealib-latest\include;..\..\..\components\utilities\ulog\backend;..\libraries\AT32F403A_407_Firmware_Library\drivers\inc;..\..\..\components\dfs\dfs_v1\include;..\..\..\components\utilities\ulog;applications\components\gnss_interface;..\..\..\components\drivers\include;..\libraries\rt_drivers;board;..\..\..\components\libc\compilers\common\extension;applications\porting\fal;applications\app_task\tsp_task\inc;..\..\..\components\drivers\include;..\..\..\components\finsh;..\libraries\rt_drivers\config;applications\components\flashdb_interface;applications;..\..\..\components\drivers\spi\sfud\inc;..\..\..\components\fal\inc;applications\app_task\can_task;..\..\..\include;..\libraries\AT32F403A_407_Firmware_Library\cmsis\cm4\core_support;..\..\..\components\drivers\include;applications\app_task\demo_cmd\inc;applications\app_task\pmu_task\inc;..\..\..\components\drivers\spi;..\..\..\components\libc\posix\io\eventfd;.;packages\TaskMsgBus-v3.0.1\inc;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\epoll;..\..\..\components\libc\posix\ipc;applications\app_task\tsp_task;applications\app_task\pmu_task;applications\app_task\comp_task\inc;packages\FlashDB-v2.1.0\inc;..\..\..\libcpu\arm\cortex-m4;..\libraries\AT32F403A_407_Firmware_Library\cmsis\cm4\device_support;..\..\..\components\libc\posix\io\poll;applications\components\ramdb_interface;applications\components\ramdb_interface\inc;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\include;..\..\..\libcpu\arm\common;applications\components\flashdb_interface\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group can_task
    applications/app_task/can_task/src/: can_task.c can_interface.c
  group comp_task
    applications/app_task/comp_task/src/: component_task.c msg_bus_interface.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group demo_cmd
    applications/app_task/demo_cmd/: can_sample.c
  group DeviceDrivers
    ../../../components/drivers/can/: can.c
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: pin.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
  group Drivers
    board/src/: at32_msp.c board.c
    ../libraries/AT32F403A_407_Firmware_Library/cmsis/cm4/device_support/startup/mdk/: startup_at32f403a_407.s
    ../libraries/rt_drivers/: drv_can.c drv_common.c drv_flash.c drv_gpio.c drv_rtc.c drv_spi.c drv_usart.c
  group Fal
    ../../../components/fal/src/: fal.c fal_partition.c fal_flash.c fal_rtt.c
    ../../../components/fal/samples/porting/: fal_flash_sfud_port.c
  group fdb_interface
    applications/components/flashdb_interface/src/: flashdb_interface.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: msh_file.c msh_parse.c cmd.c msh.c shell.c
  group FlashDB
    packages/FlashDB-v2.1.0/samples/: kvdb_basic_sample.c kvdb_type_string_sample.c tsdb_sample.c kvdb_type_blob_sample.c
    packages/FlashDB-v2.1.0/src/: fdb_cmd.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c fdb_file.c fdb.c
  group gnss_interface
    applications/components/gnss_interface/src/: gnss_interface.c
  group Kernel
    ../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/AT32F403A_407_Firmware_Library/cmsis/cm4/device_support/: system_at32f403a_407.c
    ../libraries/AT32F403A_407_Firmware_Library/drivers/src/: at32f403a_407_debug.c at32f403a_407_usart.c at32f403a_407_flash.c at32f403a_407_acc.c at32f403a_407_can.c at32f403a_407_misc.c at32f403a_407_emac.c at32f403a_407_crm.c at32f403a_407_tmr.c at32f403a_407_wdt.c at32f403a_407_exint.c at32f403a_407_dac.c at32f403a_407_bpr.c at32f403a_407_crc.c at32f403a_407_xmc.c at32f403a_407_gpio.c at32f403a_407_spi.c at32f403a_407_rtc.c at32f403a_407_pwc.c at32f403a_407_dma.c at32f403a_407_usb.c at32f403a_407_i2c.c at32f403a_407_adc.c at32f403a_407_sdio.c at32f403a_407_wwdt.c
  group nmealib
    packages/nmealib-latest/src/: generator.c tok.c info.c context.c time.c parse.c sentence.c parser.c gmath.c generate.c
  group pmu_task
    applications/app_task/pmu_task/src/: pmu_task_manage.c pmu_task.c
  group POSIX
    ../../../components/libc/posix/io/stdio/: stdio.c
  group rbd_interface
    applications/components/ramdb_interface/src/: attr_mem.c attr.c demo.c
  group rt_kprintf
    packages/rt_vsnprintf_full-latest/: rt_vsnprintf.c
  group task_msg_bus
    packages/TaskMsgBus-v3.0.1/src/: task_msg_bus.c
  group tsp_task
    applications/app_task/tsp_task/src/: tsp_task.c
  group Utilities
    ../../../components/utilities/ulog/backend/: console_be.c file_be.c
    ../../../components/utilities/ulog/: ulog.c
