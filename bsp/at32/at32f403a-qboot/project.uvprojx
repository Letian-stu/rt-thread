# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARM_COM5)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.1.5
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, USE_STDPERIPH_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, AT32F403AVGT7
  c include: ..\..\..\components\finsh;packages\quicklz-v1.0.1;..\..\..\components\drivers\include;packages\qboot-v1.06\inc;..\libraries\AT32F403A_407_Firmware_Library\cmsis\cm4\device_support;packages\ota_downloader-v1.0.0;..\..\..\components\drivers\include;..\libraries\AT32F403A_407_Firmware_Library\cmsis\cm4\core_support;..\..\..\libcpu\arm\cortex-m4;applications\porting\fal;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\epoll;..\libraries\AT32F403A_407_Firmware_Library\drivers\inc;..\..\..\include;board\inc;..\..\..\components\libc\compilers\common\extension\fcntl\octal;packages\quick_led-latest\inc;..\..\..\components\libc\compilers\common\include;.;..\libraries\rt_drivers;..\..\..\components\libc\posix\ipc;..\..\..\components\drivers\spi;applications;..\..\..\components\fal\inc;..\..\..\libcpu\arm\common;..\..\..\components\drivers\include;..\..\..\components\drivers\spi\sfud\inc;..\..\..\components\drivers\include;..\..\..\components\utilities\ulog;..\..\..\components\libc\posix\io\poll;..\libraries\rt_drivers\config;..\..\..\components\utilities\ymodem;packages\crclib-v1.02\inc;..\..\..\components\drivers\include;..\libraries\usbd_library\inc;board;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\posix\io\eventfd
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group crclib
    packages/crclib-v1.02/src/: crc16.c crc8.c crc32.c crc8_ex.c crc16_ex.c crc16_ex_sample.c crc32_ex.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    ../../../components/drivers/watchdog/: watchdog.c
  group Drivers
    board/src/: at32_msp.c board.c
    ../libraries/AT32F403A_407_Firmware_Library/cmsis/cm4/device_support/startup/mdk/: startup_at32f403a_407.s
    ../libraries/rt_drivers/: drv_common.c drv_flash.c drv_gpio.c drv_spi.c drv_usart.c drv_wdt.c
  group Fal
    ../../../components/fal/samples/porting/: fal_flash_sfud_port.c
    ../../../components/fal/src/: fal_flash.c fal_rtt.c fal_partition.c fal.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/AT32F403A_407_Firmware_Library/drivers/src/: at32f403a_407_exint.c at32f403a_407_emac.c at32f403a_407_rtc.c at32f403a_407_spi.c at32f403a_407_dac.c at32f403a_407_bpr.c at32f403a_407_gpio.c at32f403a_407_sdio.c at32f403a_407_wdt.c at32f403a_407_usart.c at32f403a_407_flash.c at32f403a_407_dma.c at32f403a_407_pwc.c at32f403a_407_acc.c at32f403a_407_can.c at32f403a_407_crm.c at32f403a_407_crc.c at32f403a_407_wwdt.c at32f403a_407_debug.c at32f403a_407_usb.c at32f403a_407_adc.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_tmr.c at32f403a_407_xmc.c
    ../libraries/AT32F403A_407_Firmware_Library/cmsis/cm4/device_support/: system_at32f403a_407.c
  group ota_downloader
    packages/ota_downloader-v1.0.0/src/: ymodem_ota.c
  group qboot
    packages/qboot-v1.06/src/: qboot_stm32.c qboot.c qboot_aes.c qboot_fastlz.c qboot_quicklz.c qboot_gzip.c qboot_at32.c
  group quick_led
    packages/quick_led-latest/src/: qled.c qled_sample.c
  group quicklz
    packages/quicklz-v1.0.1/: quicklz.c
  group Utilities
    ../../../components/utilities/ulog/backend/: console_be.c
    ../../../components/utilities/ulog/: ulog.c
    ../../../components/utilities/ymodem/: ymodem.c
